Push Button (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "WashNut", "Washer", "Cap", "Body"